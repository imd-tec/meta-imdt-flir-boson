require flir-boson-additions.inc
